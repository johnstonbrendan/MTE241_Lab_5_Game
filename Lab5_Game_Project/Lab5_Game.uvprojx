# Keil uVision project Lab5_Game.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab5_Game
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c GUI.c GUI.h Joy.c Joy.h Pot.c Pot.h pushbutton.c pushbutton.h type_declarations.h enemy.c player.c bitmaps.h enemy.h player.h bitmaps.c GLCD_Scroll.c GLCD_SPI_LPC1700.c Retarget.c uart.c cmsis_os2.h Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_Scroll.h uart.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:Startup 1.0.0
